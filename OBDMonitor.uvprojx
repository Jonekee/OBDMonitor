# Keil uVision project OBDMonitor.uvprojx, settings and files
target FLASH (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.6.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: OBDMonitor
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F407xx
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DRIVER
    ./: canbus.c nt35510.c lcd_driver.c system.c gt9147.c tp_driver.c
  group FIRMWARE
    ./: trace.c main.c mainloop.c winmgmt.c touch.c
  group APP
    ./: topmenu.c appif.c setting.c
  group GUI
    ./: button.c widget.c window.c
software components: CMSIS:CORE 4.3.0, Device:Startup 2.4.0
